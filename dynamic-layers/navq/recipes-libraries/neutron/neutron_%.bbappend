# Set firmware version to match Verdin imx95

SRCBRANCH = "lf-6.12.49_2.2.0"
SRCREV = "a7d5f17a9210c45aef2bbc9dc09d637f41fd3a7c"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=bc649096ad3928ec06a8713b8d787eac"
